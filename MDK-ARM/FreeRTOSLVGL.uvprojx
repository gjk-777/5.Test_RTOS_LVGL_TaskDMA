# Keil uVision project FreeRTOSLVGL.uvprojx, settings and files
target FreeRTOSLVGL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FreeRTOSLVGL +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --diag_suppress=1293,111
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP;../Drivers/BSP/24CXX;../Drivers/BSP/IIC;../Drivers/BSP/TOUCH;../Drivers/BSP/LVGL/keypad_encoder;../Drivers/BSP/LVGL/porting;../Drivers/BSP/LVGL/src;../Drivers/BSP/LVGL;../Core/lvgl;../Core/lvgl/patches;../Core/lvgl/src;../Core/lvgl/src/custom;../Core/lvgl/src/generated;../Core/lvgl/src/generated/guider_customer_fonts;../Core/lvgl/src/generated/guider_fonts;../Core/lvgl/src/generated/images;../Core/lvgl/dclock;../Drivers/BSP/LVGL/stress;../Drivers/BSP/LVGL/stress/assets;../Drivers/BSP/LVGL/music;../Drivers/BSP/LVGL/music/assets;../Drivers/BSP/use_flash;../Drivers/BSP/flashDB/inc;../Drivers/BSP/flashDB/port/fal/docs/figures
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c fsmc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group BSP
    ../Drivers/BSP/: lcd.c keyled.c My_Touch.c My_TaskCreate.c My_TaskCreate.h sram.c CAN_handle.c CAN_handle.h
    ../Drivers/BSP/use_flash/: use_iap_flash.c use_iap_flash.h test_iap_flash.c test_iap_flash.h norflash.c norflash.h
  group Touch
    ../Drivers/BSP/24CXX/: 24cxx.c
    ../Drivers/BSP/IIC/: myiic.c
    ../Drivers/BSP/TOUCH/: ctiic.c touch.c ft5206.c gt9xxx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group LVGL_Src
    ../Drivers/BSP/LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../Drivers/BSP/LVGL/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../Drivers/BSP/LVGL/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ../Drivers/BSP/LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../Drivers/BSP/LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../Drivers/BSP/LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../Drivers/BSP/LVGL/src/draw/: lv_img_decoder.c lv_img_cache.c lv_img_buf.c lv_draw_triangle.c lv_draw_rect.c lv_draw_mask.c lv_draw_line.c lv_draw_label.c lv_draw_img.c lv_draw_arc.c lv_draw.c
    ../Drivers/BSP/LVGL/src/extra/layouts/flex/: lv_flex.c
    ../Drivers/BSP/LVGL/src/extra/layouts/grid/: lv_grid.c
    ../Drivers/BSP/LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../Drivers/BSP/LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Drivers/BSP/LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../Drivers/BSP/LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Drivers/BSP/LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Drivers/BSP/LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../Drivers/BSP/LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Drivers/BSP/LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../Drivers/BSP/LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Drivers/BSP/LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../Drivers/BSP/LVGL/src/extra/others/monkey/: lv_monkey.c
    ../Drivers/BSP/LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../Drivers/BSP/LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../Drivers/BSP/LVGL/src/extra/themes/default/: lv_theme_default.c
    ../Drivers/BSP/LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../Drivers/BSP/LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../Drivers/BSP/LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Drivers/BSP/LVGL/src/extra/widgets/chart/: lv_chart.c
    ../Drivers/BSP/LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Drivers/BSP/LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Drivers/BSP/LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Drivers/BSP/LVGL/src/extra/widgets/led/: lv_led.c
    ../Drivers/BSP/LVGL/src/extra/widgets/list/: lv_list.c
    ../Drivers/BSP/LVGL/src/extra/widgets/menu/: lv_menu.c
    ../Drivers/BSP/LVGL/src/extra/widgets/meter/: lv_meter.c
    ../Drivers/BSP/LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Drivers/BSP/LVGL/src/extra/widgets/span/: lv_span.c
    ../Drivers/BSP/LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Drivers/BSP/LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../Drivers/BSP/LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../Drivers/BSP/LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../Drivers/BSP/LVGL/src/extra/widgets/win/: lv_win.c
    ../Drivers/BSP/LVGL/src/extra/: lv_extra.c
    ../Drivers/BSP/LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Drivers/BSP/LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../Drivers/BSP/LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../Drivers/BSP/LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_Por
    ../Drivers/BSP/LVGL/porting/: lv_port_disp.c lv_port_disp.h lv_port_fs.c lv_port_fs.h lv_port_indev.c lv_port_indev.h
    ../Drivers/BSP/LVGL/: lv_conf.h lvgl.h
  group LVGL_Demo
    ../Drivers/BSP/LVGL/keypad_encoder/: lv_demo_keypad_encoder.c lv_demo_keypad_encoder.h
    ../Drivers/BSP/LVGL/: lv_demos.h
    ../Drivers/BSP/LVGL/stress/: lv_demo_stress.c
    ../Drivers/BSP/LVGL/stress/assets/: lv_font_montserrat_12_compr_az.c lv_font_montserrat_16_compr_az.c lv_font_montserrat_28_compr_az.c
  group LVGL_App
    ../Core/lvgl/src/custom/: custom.c password.c
    ../Core/lvgl/src/generated/: events_init.c gui_guider.c setup_scr_screen.c setup_scr_screen_1.c setup_scr_screen_2.c widgets_init.c
    ../Core/lvgl/src/generated/guider_fonts/: lv_font_arial_16.c lv_font_montserratMedium_12.c lv_font_montserratMedium_16.c lv_font_montserratMedium_18.c lv_font_SourceHanSerifSC_Regular_12.c lv_font_SourceHanSerifSC_Regular_16.c
    ../Core/lvgl/src/generated/images/: _clock_alpha_30x30.c _led0_alpha_30x30.c _led0_alpha_40x34.c _led1_alpha_30x30.c _ledoff_alpha_30x30.c _lighthigh_alpha_30x30.c
    ../Core/lvgl/dclock/: lv_dclock.c
software components: CMSIS:CORE 4.3.0
